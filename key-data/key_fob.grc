<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>key_fob</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_freq</value></param>
<param><key>value</key><value>315e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>0.5*data_freq</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>comment</key><value>FSK Demodulator</value></param>
<param><key>gain</key><value>6</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>comment</key><value>The majority of signal (at any frequency) is 
garbage. By taking the magnitiude of the signal's 
compex value, it focuses my attention on the 
transmission rather than the noise.</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>2</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>-2</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>high</key><value>0.5</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[0.000231527825235,0.000234239312704,0.000236250809394,0.000237546671997,0.000238107997575,0.000237912579905,0.000236935098656,0.000235147163039,0.000232517544646,0.000229012468481,0.000224595947657,0.000219230088987,0.000212875645957,0.000205492528039,0.000197040237254,0.00018747865397,0.000176768488018,0.000164872195455,0.000151754473336,0.000137383205583,0.00012173014693,0.000104771679617,8.64897010615e-05,6.68723514536e-05,4.59148322989e-05,2.36201776715e-05,-1.81699307609e-19,-2.49247877946e-05,-5.11232901772e-05,-7.85539887147e-05,-0.000107164174551,-0.000136889400892,-0.000167653110111,-0.000199366128072,-0.000231926489505,-0.000265219248831,-0.00029911621823,-0.000333476200467,-0.000368144916138,-0.000402955134632,-0.000437727285316,-0.000472269632155,-0.000506378943101,-0.000539841304999,-0.000572432240006,-0.000603918742854,-0.000634059135336,-0.000662605161779,-0.00068930251291,-0.000713892513886,-0.000736113579478,-0.000755702785682,-0.000772397150286,-0.000785935786553,-0.000796061533038,-0.000802522758022,-0.000805075163953,-0.000803483999334,-0.00079752568854,-0.000786990160123,-0.000771682534833,-0.000751425453927,-0.000726060708985,-0.000695451453794,-0.000659483775962,-0.000618068908807,-0.000571144802961,-0.000518677639775,-0.000460663810372,-0.000397130846977,-0.000328139169142,-0.000253783073276,-0.000174191751285,-8.9530236437e-05,5.15802274534e-19,9.41605103435e-05,0.000192675579456,0.000295232137432,0.000401479919674,0.000511031714268,0.000623464118689,0.000738318136428,0.000855100341141,0.000973284244537,0.00109231157694,0.00121159409173,0.00133051571902,0.00144843477756,0.00156468641944,0.00167858507484,0.00178942736238,0.00189649546519,0.00199906039052,0.00209638522938,0.00218772841617,0.00227234931663,0.00234950892627,0.00241847732104,0.00247853551991,0.00252898084,0.00256913085468,0.00259832805023,0.00261594355106,0.00262138177641,0.00261408556253,0.00259353849106,0.00255927280523,0.00251086824574,0.00244796229526,0.00237024785019,0.00227748183534,0.00216948683374,0.00204615318216,0.00190744444262,0.00175339903217,0.00158413290046,0.00139984139241,0.00120080204215,0.000987375737168,0.000760008173529,0.000519230263308,0.000265659706201,-1.01582566529e-18,-0.000276959151961,-0.000564342597499,-0.000861190957949,-0.00116646196693,-0.00147903256584,-0.0017977009993,-0.00212119030766,-0.00244814972393,-0.00277716084383,-0.00310673983768,-0.00343534140848,-0.00376136624254,-0.00408316263929,-0.00439903559163,-0.00470724981278,-0.00500603625551,-0.00529360119253,-0.00556812994182,-0.00582779385149,-0.00607076147571,-0.00629520043731,-0.00649929000065,-0.00668122339994,-0.00683922227472,-0.00697153853253,-0.00707646459341,-0.00715234316885,-0.00719757052138,-0.00721061043441,-0.00718999560922,-0.00713433837518,-0.00704233907163,-0.00691279023886,-0.00674458453432,-0.0065367249772,-0.00628832355142,-0.00599861424416,-0.00566695583984,-0.00529283517972,-0.00487587600946,-0.00441583991051,-0.0039126300253,-0.00336629664525,-0.00277703767642,-0.00214520166628,-0.00147128861863,-0.000755952554755,1.45190432409e-18,0.000795609375928,0.00162976351567,0.00250119995326,0.0034085076768,0.00435012951493,0.0053243660368,0.00632937951013,0.00736319785938,0.00842371955514,0.00950872059911,0.010615860112,0.0117426859215,0.0128866462037,0.0140450866893,0.0152152758092,0.0163943935186,0.0175795610994,0.0187678299844,0.0199562069029,0.0211416557431,0.0223211105913,0.0234914887697,0.024649694562,0.0257926359773,0.0269172322005,0.028020426631,0.0290991924703,0.0301505569369,0.0311715919524,0.0321594402194,0.0331113226712,0.0340245440602,0.0348965004086,0.0357247069478,0.0365067720413,0.0372404493392,0.0379236079752,0.0385542698205,0.0391305945814,0.0396508947015,0.0401136465371,0.0405174978077,0.04086124897,0.0411439016461,0.0413646101952,0.0415227264166,0.0416177846491,0.0416495017707,0.0416177846491,0.0415227264166,0.0413646101952,0.0411439016461,0.04086124897,0.0405174978077,0.0401136465371,0.0396508947015,0.0391305945814,0.0385542698205,0.0379236079752,0.0372404493392,0.0365067720413,0.0357247069478,0.0348965004086,0.0340245440602,0.0331113226712,0.0321594402194,0.0311715919524,0.0301505569369,0.0290991924703,0.028020426631,0.0269172322005,0.0257926359773,0.024649694562,0.0234914887697,0.0223211105913,0.0211416557431,0.0199562069029,0.0187678299844,0.0175795610994,0.0163943935186,0.0152152758092,0.0140450866893,0.0128866462037,0.0117426859215,0.010615860112,0.00950872059911,0.00842371955514,0.00736319785938,0.00632937951013,0.0053243660368,0.00435012951493,0.0034085076768,0.00250119995326,0.00162976351567,0.000795609375928,1.45190432409e-18,-0.000755952554755,-0.00147128861863,-0.00214520166628,-0.00277703767642,-0.00336629664525,-0.0039126300253,-0.00441583991051,-0.00487587600946,-0.00529283517972,-0.00566695583984,-0.00599861424416,-0.00628832355142,-0.0065367249772,-0.00674458453432,-0.00691279023886,-0.00704233907163,-0.00713433837518,-0.00718999560922,-0.00721061043441,-0.00719757052138,-0.00715234316885,-0.00707646459341,-0.00697153853253,-0.00683922227472,-0.00668122339994,-0.00649929000065,-0.00629520043731,-0.00607076147571,-0.00582779385149,-0.00556812994182,-0.00529360119253,-0.00500603625551,-0.00470724981278,-0.00439903559163,-0.00408316263929,-0.00376136624254,-0.00343534140848,-0.00310673983768,-0.00277716084383,-0.00244814972393,-0.00212119030766,-0.0017977009993,-0.00147903256584,-0.00116646196693,-0.000861190957949,-0.000564342597499,-0.000276959151961,-1.01582566529e-18,0.000265659706201,0.000519230263308,0.000760008173529,0.000987375737168,0.00120080204215,0.00139984139241,0.00158413290046,0.00175339903217,0.00190744444262,0.00204615318216,0.00216948683374,0.00227748183534,0.00237024785019,0.00244796229526,0.00251086824574,0.00255927280523,0.00259353849106,0.00261408556253,0.00262138177641,0.00261594355106,0.00259832805023,0.00256913085468,0.00252898084,0.00247853551991,0.00241847732104,0.00234950892627,0.00227234931663,0.00218772841617,0.00209638522938,0.00199906039052,0.00189649546519,0.00178942736238,0.00167858507484,0.00156468641944,0.00144843477756,0.00133051571902,0.00121159409173,0.00109231157694,0.000973284244537,0.000855100341141,0.000738318136428,0.000623464118689,0.000511031714268,0.000401479919674,0.000295232137432,0.000192675579456,9.41605103435e-05,5.15802274534e-19,-8.9530236437e-05,-0.000174191751285,-0.000253783073276,-0.000328139169142,-0.000397130846977,-0.000460663810372,-0.000518677639775,-0.000571144802961,-0.000618068908807,-0.000659483775962,-0.000695451453794,-0.000726060708985,-0.000751425453927,-0.000771682534833,-0.000786990160123,-0.00079752568854,-0.000803483999334,-0.000805075163953,-0.000802522758022,-0.000796061533038,-0.000785935786553,-0.000772397150286,-0.000755702785682,-0.000736113579478,-0.000713892513886,-0.00068930251291,-0.000662605161779,-0.000634059135336,-0.000603918742854,-0.000572432240006,-0.000539841304999,-0.000506378943101,-0.000472269632155,-0.000437727285316,-0.000402955134632,-0.000368144916138,-0.000333476200467,-0.00029911621823,-0.000265219248831,-0.000231926489505,-0.000199366128072,-0.000167653110111,-0.000136889400892,-0.000107164174551,-7.85539887147e-05,-5.11232901772e-05,-2.49247877946e-05,-1.81699307609e-19,2.36201776715e-05,4.59148322989e-05,6.68723514536e-05,8.64897010615e-05,0.000104771679617,0.00012173014693,0.000137383205583,0.000151754473336,0.000164872195455,0.000176768488018,0.00018747865397,0.000197040237254,0.000205492528039,0.000212875645957,0.000219230088987,0.000224595947657,0.000229012468481,0.000232517544646,0.000235147163039,0.000236935098656,0.000237912579905,0.000238107997575,0.000237546671997,0.000236250809394,0.000234239312704,0.000231527825235]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[0.000231527825235,0.000234239312704,0.000236250809394,0.000237546671997,0.000238107997575,0.000237912579905,0.000236935098656,0.000235147163039,0.000232517544646,0.000229012468481,0.000224595947657,0.000219230088987,0.000212875645957,0.000205492528039,0.000197040237254,0.00018747865397,0.000176768488018,0.000164872195455,0.000151754473336,0.000137383205583,0.00012173014693,0.000104771679617,8.64897010615e-05,6.68723514536e-05,4.59148322989e-05,2.36201776715e-05,-1.81699307609e-19,-2.49247877946e-05,-5.11232901772e-05,-7.85539887147e-05,-0.000107164174551,-0.000136889400892,-0.000167653110111,-0.000199366128072,-0.000231926489505,-0.000265219248831,-0.00029911621823,-0.000333476200467,-0.000368144916138,-0.000402955134632,-0.000437727285316,-0.000472269632155,-0.000506378943101,-0.000539841304999,-0.000572432240006,-0.000603918742854,-0.000634059135336,-0.000662605161779,-0.00068930251291,-0.000713892513886,-0.000736113579478,-0.000755702785682,-0.000772397150286,-0.000785935786553,-0.000796061533038,-0.000802522758022,-0.000805075163953,-0.000803483999334,-0.00079752568854,-0.000786990160123,-0.000771682534833,-0.000751425453927,-0.000726060708985,-0.000695451453794,-0.000659483775962,-0.000618068908807,-0.000571144802961,-0.000518677639775,-0.000460663810372,-0.000397130846977,-0.000328139169142,-0.000253783073276,-0.000174191751285,-8.9530236437e-05,5.15802274534e-19,9.41605103435e-05,0.000192675579456,0.000295232137432,0.000401479919674,0.000511031714268,0.000623464118689,0.000738318136428,0.000855100341141,0.000973284244537,0.00109231157694,0.00121159409173,0.00133051571902,0.00144843477756,0.00156468641944,0.00167858507484,0.00178942736238,0.00189649546519,0.00199906039052,0.00209638522938,0.00218772841617,0.00227234931663,0.00234950892627,0.00241847732104,0.00247853551991,0.00252898084,0.00256913085468,0.00259832805023,0.00261594355106,0.00262138177641,0.00261408556253,0.00259353849106,0.00255927280523,0.00251086824574,0.00244796229526,0.00237024785019,0.00227748183534,0.00216948683374,0.00204615318216,0.00190744444262,0.00175339903217,0.00158413290046,0.00139984139241,0.00120080204215,0.000987375737168,0.000760008173529,0.000519230263308,0.000265659706201,-1.01582566529e-18,-0.000276959151961,-0.000564342597499,-0.000861190957949,-0.00116646196693,-0.00147903256584,-0.0017977009993,-0.00212119030766,-0.00244814972393,-0.00277716084383,-0.00310673983768,-0.00343534140848,-0.00376136624254,-0.00408316263929,-0.00439903559163,-0.00470724981278,-0.00500603625551,-0.00529360119253,-0.00556812994182,-0.00582779385149,-0.00607076147571,-0.00629520043731,-0.00649929000065,-0.00668122339994,-0.00683922227472,-0.00697153853253,-0.00707646459341,-0.00715234316885,-0.00719757052138,-0.00721061043441,-0.00718999560922,-0.00713433837518,-0.00704233907163,-0.00691279023886,-0.00674458453432,-0.0065367249772,-0.00628832355142,-0.00599861424416,-0.00566695583984,-0.00529283517972,-0.00487587600946,-0.00441583991051,-0.0039126300253,-0.00336629664525,-0.00277703767642,-0.00214520166628,-0.00147128861863,-0.000755952554755,1.45190432409e-18,0.000795609375928,0.00162976351567,0.00250119995326,0.0034085076768,0.00435012951493,0.0053243660368,0.00632937951013,0.00736319785938,0.00842371955514,0.00950872059911,0.010615860112,0.0117426859215,0.0128866462037,0.0140450866893,0.0152152758092,0.0163943935186,0.0175795610994,0.0187678299844,0.0199562069029,0.0211416557431,0.0223211105913,0.0234914887697,0.024649694562,0.0257926359773,0.0269172322005,0.028020426631,0.0290991924703,0.0301505569369,0.0311715919524,0.0321594402194,0.0331113226712,0.0340245440602,0.0348965004086,0.0357247069478,0.0365067720413,0.0372404493392,0.0379236079752,0.0385542698205,0.0391305945814,0.0396508947015,0.0401136465371,0.0405174978077,0.04086124897,0.0411439016461,0.0413646101952,0.0415227264166,0.0416177846491,0.0416495017707,0.0416177846491,0.0415227264166,0.0413646101952,0.0411439016461,0.04086124897,0.0405174978077,0.0401136465371,0.0396508947015,0.0391305945814,0.0385542698205,0.0379236079752,0.0372404493392,0.0365067720413,0.0357247069478,0.0348965004086,0.0340245440602,0.0331113226712,0.0321594402194,0.0311715919524,0.0301505569369,0.0290991924703,0.028020426631,0.0269172322005,0.0257926359773,0.024649694562,0.0234914887697,0.0223211105913,0.0211416557431,0.0199562069029,0.0187678299844,0.0175795610994,0.0163943935186,0.0152152758092,0.0140450866893,0.0128866462037,0.0117426859215,0.010615860112,0.00950872059911,0.00842371955514,0.00736319785938,0.00632937951013,0.0053243660368,0.00435012951493,0.0034085076768,0.00250119995326,0.00162976351567,0.000795609375928,1.45190432409e-18,-0.000755952554755,-0.00147128861863,-0.00214520166628,-0.00277703767642,-0.00336629664525,-0.0039126300253,-0.00441583991051,-0.00487587600946,-0.00529283517972,-0.00566695583984,-0.00599861424416,-0.00628832355142,-0.0065367249772,-0.00674458453432,-0.00691279023886,-0.00704233907163,-0.00713433837518,-0.00718999560922,-0.00721061043441,-0.00719757052138,-0.00715234316885,-0.00707646459341,-0.00697153853253,-0.00683922227472,-0.00668122339994,-0.00649929000065,-0.00629520043731,-0.00607076147571,-0.00582779385149,-0.00556812994182,-0.00529360119253,-0.00500603625551,-0.00470724981278,-0.00439903559163,-0.00408316263929,-0.00376136624254,-0.00343534140848,-0.00310673983768,-0.00277716084383,-0.00244814972393,-0.00212119030766,-0.0017977009993,-0.00147903256584,-0.00116646196693,-0.000861190957949,-0.000564342597499,-0.000276959151961,-1.01582566529e-18,0.000265659706201,0.000519230263308,0.000760008173529,0.000987375737168,0.00120080204215,0.00139984139241,0.00158413290046,0.00175339903217,0.00190744444262,0.00204615318216,0.00216948683374,0.00227748183534,0.00237024785019,0.00244796229526,0.00251086824574,0.00255927280523,0.00259353849106,0.00261408556253,0.00262138177641,0.00261594355106,0.00259832805023,0.00256913085468,0.00252898084,0.00247853551991,0.00241847732104,0.00234950892627,0.00227234931663,0.00218772841617,0.00209638522938,0.00199906039052,0.00189649546519,0.00178942736238,0.00167858507484,0.00156468641944,0.00144843477756,0.00133051571902,0.00121159409173,0.00109231157694,0.000973284244537,0.000855100341141,0.000738318136428,0.000623464118689,0.000511031714268,0.000401479919674,0.000295232137432,0.000192675579456,9.41605103435e-05,5.15802274534e-19,-8.9530236437e-05,-0.000174191751285,-0.000253783073276,-0.000328139169142,-0.000397130846977,-0.000460663810372,-0.000518677639775,-0.000571144802961,-0.000618068908807,-0.000659483775962,-0.000695451453794,-0.000726060708985,-0.000751425453927,-0.000771682534833,-0.000786990160123,-0.00079752568854,-0.000803483999334,-0.000805075163953,-0.000802522758022,-0.000796061533038,-0.000785935786553,-0.000772397150286,-0.000755702785682,-0.000736113579478,-0.000713892513886,-0.00068930251291,-0.000662605161779,-0.000634059135336,-0.000603918742854,-0.000572432240006,-0.000539841304999,-0.000506378943101,-0.000472269632155,-0.000437727285316,-0.000402955134632,-0.000368144916138,-0.000333476200467,-0.00029911621823,-0.000265219248831,-0.000231926489505,-0.000199366128072,-0.000167653110111,-0.000136889400892,-0.000107164174551,-7.85539887147e-05,-5.11232901772e-05,-2.49247877946e-05,-1.81699307609e-19,2.36201776715e-05,4.59148322989e-05,6.68723514536e-05,8.64897010615e-05,0.000104771679617,0.00012173014693,0.000137383205583,0.000151754473336,0.000164872195455,0.000176768488018,0.00018747865397,0.000197040237254,0.000205492528039,0.000212875645957,0.000219230088987,0.000224595947657,0.000229012468481,0.000232517544646,0.000235147163039,0.000236935098656,0.000237912579905,0.000238107997575,0.000237546671997,0.000236250809394,0.000234239312704,0.000231527825235]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>315e6</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>500000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>500000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_delay</key><value>-.1</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value></value></param>
<param><key>style1</key><value>4</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>500000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>data_freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>6</value></param>
<param><key>args</key><value></value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_threshold_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
